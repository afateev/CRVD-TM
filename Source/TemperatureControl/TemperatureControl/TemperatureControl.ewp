# IAR project TemperatureControl.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: STM32F10xx6 ST STM32F10xx6
  ICCARM.CCDefines: STM32F1
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: TemperatureControl.bin
  ILINK.IlinkOutputFile: TemperatureControl.out
  ILINK.IlinkIcfFile: TemperatureControl.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: 5.srec
  group (top)
    ./: main.cpp
