# IAR project Test.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F405VG ST STM32F405VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F4; USE_HAL_DRIVER; STM32F405xx
  ICCARM.CCIncludePath2: Inc; ..\RBLib\STM32Cube_FW_F4\Drivers\CMSIS\Device\ST\STM32F4xx\Include; ..\RBLib\STM32Cube_FW_F4\Drivers\STM32F4xx_HAL_Driver\Inc; ..\RBLib\STM32Cube_FW_F4\Drivers\BSP\STM32F429I-Discovery; ..\RBLib\STM32Cube_FW_F4\Middlewares\ST\STM32_USB_HOST_Library\Core\Inc; ..\RBLib\STM32Cube_FW_F4\Middlewares\ST\STM32_USB_HOST_Library\Class\MSC\Inc; ..\RBLib\STM32Cube_FW_F4\Middlewares\Third_Party\FatFs\src; ..\RBLib\STM32Cube_FW_F4\Middlewares\Third_Party\FatFs\src\drivers
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: Test.bin
  ILINK.IlinkOutputFile: cpp.out
  ILINK.IlinkIcfFile: Test.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: 5.srec
  group (top)
    ./: main.cpp
  group Application/User
    Src/: usbh_conf.c
  group Drivers/CMSIS
    Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Drivers
    ../RBLib/STM32Cube_FW_F4/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hcd.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c stm32f4xx_ll_usb.c
  group Middlewares/FatFs/Core
    ../RBLib/STM32Cube_FW_F4/Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group Middlewares/FatFs/Drivers
    ../RBLib/STM32Cube_FW_F4/Middlewares/Third_Party/FatFs/src/drivers/: usbh_diskio.c
  group Middlewares/STM32_USBH_Library/Class/MSC
    ../RBLib/STM32Cube_FW_F4/Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc.c usbh_msc_bot.c usbh_msc_scsi.c
  group Middlewares/STM32_USBH_Library/Core
    ../RBLib/STM32Cube_FW_F4/Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
