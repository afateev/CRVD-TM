# IAR project MainPanel.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: STM32F107xC ST STM32F107xC
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 2
  OBJCOPY.OOCOutputFile: MainPanel.bin
  ILINK.IlinkOutputFile: MainPanel.out
  ILINK.IlinkIcfFile: MainPanel.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: 5.srec
  group (top)
    ./: Config.h Control.h ControlButton.h ControlCharInput.h ControlTextInput.h cstartup.s Desctop.h DesctopStack.h DriveController.h DriveControllerParams.h DriveControllerSwitch.h DriveEventsGenerator.h Events.h InsulationControl.h KeyboardScanner.h main.cpp Menu.h OscFileFormat.h OscGetter.h PortScanner.h SevenSegmentDigit.h SideIndicators.h Window.h WindowConfigSystemDateTime.h WindowControllerNominalStatorCurrent.h WindowDebugRegisters.h WindowEditRegValue.h WindowEvents.h WindowGraph.h WindowMain.h WindowOscList.h WindowResetOperatingTime.h Windows.h
  group fat_filelib
    fat_filelib/: fat_access.c fat_access.h fat_cache.c fat_cache.h fat_defs.h fat_filelib.c fat_filelib.h fat_format.c fat_format.h fat_list.h fat_misc.c fat_misc.h fat_opts.h fat_string.c fat_string.h fat_table.c fat_table.h fat_types.h fat_write.c fat_write.h
  group MegaLib
    MegaLib/: Afio.h Display.h DrawContext.h FBGFont.h Font.h Fonts.h Gpio.h InterruptMap.h MAX6951.h MegaLib.h PowerControl.h RegisterReference.h ResetAndClockControl.h Rtc.h Screen.h ScreenBuffer.h SoftwareSpi.h Spi.h Timer.h Usart.h Usb.h
  group MegaLib/lcd
    MegaLib/lcd/: Bus6800.h RA8835.h ScreenRA8835.h
  group MegaLib/mmc
    MegaLib/mmc/: mmc.h
  group MegaLib/ModBus
    MegaLib/ModBus/: ModBus.h ModBusCrc.h ModBusMaster.h ModBusSlave.h ModBusStateMachine.h
  group MegaLib/stm32/f107
    MegaLib/stm32/f107/: Afio.h AfioParts.h Gpio.h GpioParts.h InterruptController.h InterruptMap.h PowerControl.h PowerControlParts.h ResetAndClockControl.h ResetAndClockControlParts.h Rtc.h RtcParts.h Spi.h SpiParts.h Timer.h TimerBasicParts.h Usart.h UsartParts.h Usb.h UsbParts.h
